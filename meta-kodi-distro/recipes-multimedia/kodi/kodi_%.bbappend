FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-addon-manifest.xml-Add-service.libreelec.settings.patch"
