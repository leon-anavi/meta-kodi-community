# Remove GUI
PACKAGECONFIG_remove = "x11 gtkgui"
